Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-13T15:19:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 13 15:19:10 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\721d1c3f-d4f4-45d8-b3c2-8c0b19724b02\f3c01445-f452-40c7-a538-fa200cb20d04\ifc * Database version: 5507 * Database creation date: Tue May 13 15:19:10 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 13 15:19:10 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 13 15:19:10 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_330833
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6317, Spot_Skel_6316_6317_Nordecor_IFC:6317:330833
In: Nível 1
Type - Material: Metal - Alumínio - Preto, LED, Plástico - Policarbonato - Translúcido
Type - Cotas - Comprimento do spot: 60 mm; Diâmetro do spot: 90 mm
Type - Dados - Data da atualização: 12/05/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot de sobrepor SKEL, acabamento preto, LED 5W 3000K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 Anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6317; Nome do tipo: 6317; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6317.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-de-sobrepor-skel-7w-3-000k/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.302
Type - Fotométricos - Fluxo luminoso: 560 lm; Grau de abertura: 24 deg; IRC (RA): >80; Potência: 7 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 6317 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Spot_Skel_6316_6317_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6317; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Ângulo de inclinação: 0 deg; Área: 0.0246768 m2; Volume: 0.00033422 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Ângulo de inclinação em radianos: 0 deg; Ângulo luminária: 0 deg; Deslocamento da luminária: 38.5 mm; Família: Spot_Skel_6316_6317_Nordecor_IFC: 6317; Família e tipo: Spot_Skel_6316_6317_Nordecor_IFC: 6317; h desloc. lum: 24 mm; ID de tipo: Spot_Skel_6316_6317_Nordecor_IFC: 6317; Tipo: Spot_Skel_6316_6317_Nordecor_IFC: 6317
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
